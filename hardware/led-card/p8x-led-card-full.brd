# Repository ksr/p8x (continued)

## EAGLE design hardware/regbank-card/p8x-regbank-card-full.brd

File hardware/regbank-card/README.md:

# Register Bank Card

> **Theory of operation:** [p8x-regbank-card-theory.md](p8x-regbank-card-theory.md) — deep walkthrough of inputs/outputs, signal flow, and logic.

The largest card and the architectural centerpiece of the P8X (rev D, 53 ICs). It
holds the four 16-bit pointer registers **P0–P3**, the two hidden microcode scratch
pointers **PT** and **PT2**, and **always drives the address bus** — there is no
separate MAR. Every memory access is "select a pointer, drive its value on
A0–A15, optionally increment/decrement at the clock edge."

| Pointer | Role |
|---------|------|
| P0 | Program counter |
| P1, P2 | General pointers (indirect addressing modes) |
| P3 | Stack pointer (empty-descending) |
| PT (PSEL=4) | Hidden scratch pointer: absolute addressing, the 16-bit ops, `MOVW`'s read cursor |
| PT2 (PSEL=5) | Second hidden scratch pointer: `MOVW`'s write cursor (rev D) |

> This README describes the circuit as actually built in
> [`generators/gen_eagle.py`](../../generators/gen_eagle.py). See
> [p8x-system-design.md §4](../../docs/p8x-system-design.md) for the architecture and
> [p8x-bus-definition.md](../backplane/p8x-bus-definition.md) for bus pins.

## Chip inventory

| Ref | Device | Role |
|-----|--------|------|
| U1–U16 | 74169 | The four pointers — 4 synchronous up/down counters each (16 bits) |
| U17–U24 | 74244 | Pointer-select buffers — gate the selected pointer onto the on-card pointer bus (2 per pointer) |
| U25, U26 | 74244 | Address-bus drivers — pointer bus → backplane A0–A15 (always enabled) |
| U27, U28 | 74257 | Readback byte mux — pick low or high byte of the selected pointer |
| U29 | 74244 | Readback driver — selected byte → data bus D0–D7 |
| U30 | 74138 | DLD decoder (load low / load high) |
| U31 | 74138 | DOE decoder (read low / read high) |
| U32 | 74139 | Load decoder — which of P0–P3 gets the byte loaded |
| U33 | 74138 | Select decoder — `-SEL0..5` from the 3-bit PSEL: which pointer drives the address bus |
| U34 | 7402 | NOR — count request (`PINC` or `PDEC`) |
| U35 | 74HCT14 | Inverters — up/down direction and byte select |
| U36 | 74244 | Forced-zero buffer for the P0 reset trick |
| U37, U38 | 74HCT08 | AND glue — reset-gated P0 loads, readback/load enables, LED drive |
| U39 | 74138 | Count decoder — `-CNT0..5` from the 3-bit PSEL: which pointer counts |
| U40 | 74HCT32 | OR — PSEL2 gating of the U32 load decoder; PT load strobes `-LDL4`/`-LDH4` |
| U41–U44 | 74169 | PT, four counters (16 bits) |
| U45–U48 | 74169 | PT2, four counters (16 bits) |
| U49, U50 | 74244 | PT select buffers onto the pointer bus |
| U51, U52 | 74244 | PT2 select buffers onto the pointer bus |
| U53 | 74HCT32 | OR — PT2 load strobes `-LDL5`/`-LDH5` |

## How it works

### The pointers (74169 cascade)
Each pointer is **four 74169** synchronous up/down counters, 4 bits apiece. They
are cascaded for full 16-bit carry/borrow: the master count enable (`-CNTp`) drives
every slice's `!ENP`, the first slice's `!ENT` is tied low (the standard 74169
cascade), and each later slice's `!ENT` is fed from the previous slice's active-low
ripple carry `!RCO`. PT and PT2 are built the same way. Because the 74169 is *fully synchronous* (one clock + a direction pin),
load/increment/decrement all take effect cleanly on the rising clock edge — no
glitchy dual-clock behaviour like the 74193.

### Driving the address bus
PSEL0–2 (from the control card) go into the U33 74138, whose one-hot `-SEL0..5`
enables one pointer's pair of 74244 buffers (U17–U24 for P0–P3, U49/U50 for PT,
U51/U52 for PT2), gating that pointer's 16 bits onto an on-card **pointer bus**. U25/U26 (74244, permanently
enabled) drive that pointer bus straight onto backplane **A0–A15**. This card owns
the address bus — nothing else ever drives it.

### Increment / decrement
`PINC` and `PDEC` are NOR'd in U34; if either is asserted, the U39 count decoder
(74138, the full 3-bit PSEL) is enabled and pulls the selected pointer's `-CNTp`
low, so only that pointer counts — PT and PT2 included. `PDEC` (inverted in U35 → `UDB`) sets the 74169 up/down direction. The
enable and direction reach all four slices so carry/borrow propagates across the
full 16 bits.

### Byte load (writing a pointer)
DLD codes 8 (low) and 9 (high) are decoded by U30 into `-LDL`/`-LDH`, which gate the
U32 load decoder (gated off by PSEL2 through U40). Combined with PSEL0–1, U32
produces eight strobes (P0–P3 × 2 bytes); U40 and U53 make PT's and PT2's strobes
from `-LDL`/`-LDH` and `-SEL4`/`-SEL5`. A byte load asserts `!LOAD` on just the two 74169 slices of that byte; the
other byte's slices simply hold. The load data comes from the data bus (D0–D7) on
the 74169 parallel inputs.

### Byte readback (reading a pointer)
DOE codes 8/9 are decoded by U31 into `-POEL`/`-POEH`. The high/low select (`POEHP`)
drives the U27/U28 74257 muxes to pick the high or low byte of the selected
pointer's value, and U29 (74244) drives that byte onto D0–D7. `-POE` (= either byte
requested) enables U29.

### Reset → P0 = $0000
This is the clever bit. On `-RES`:
- U36, a 74244 with all inputs grounded, is enabled and drives **$00** onto the
  data bus.
- U37 ANDs `-RES` with the P0 load strobes (`-LDL0E`/`-LDH0E`), forcing P0's eight
  74169 slices to **load** every clock during reset.
- So P0 synchronously loads the zeros U36 is driving → the PC starts at $0000.

### Timing note (empty-descending stack)
Because the 74169s are synchronous, during a microcycle the *current* (pre-change)
value drives the address bus while load/inc/dec take effect only at the edge. So
"write to memory at P3 and decrement P3" in one cycle uses the pre-decrement
address — exactly what push-then-decrement wants. Pop is the mirror: increment,
then read.

## LEDs
PWR (green), RD (green — pointer readback active), LD (yellow — pointer load active).

Schematic: p8x-regbank-card.sch

Parts:
CD1, CD2, CD3, CD4, CD5, CD6, CD7, CD8, CD9, CD10, CD11, CD12, CD13, CD14, CD15, CD16, CD17, CD18, CD19, CD20, CD21, CD22, CD23, CD24, CD25, CD26, CD27, CD28, CD29, CD30, CD31, CD32, CD33, CD34, CD35, CD36, CD37, CD38, CD39, CD40, CD41, CD42, CD43, CD44: 100nF; C_DISC1
J1: MABC96R
LED3, LED4: GRN; LED5
LED5: YEL; LED5
R4, R5: 1K; R_AXIAL
RP1: 1K; R_AXIAL
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: 74HCT169; DIP16
U17, U18, U19, U20, U21, U22, U23, U24, U25, U26, U29, U36, U43, U44: 74HCT244; DIP20
U27, U28: 74HCT257; DIP16
U30, U31, U33: 74HCT138; DIP16
U32, U39: 74HCT139; DIP16
U34: 74HCT02; DIP14
U35: 74HCT14; DIP14
U37, U38: 74HCT08; DIP14
U40: 74HCT32; DIP14
U41, U42: 74HCT377; DIP20

Connections:
-CNT0: U1.7 (!ENP), U1.10 (!ENT), U2.7 (!ENP), U3.7 (!ENP), U4.7 (!ENP), U39.4 (1Y0)
-CNT1: U5.7 (!ENP), U5.10 (!ENT), U6.7 (!ENP), U7.7 (!ENP), U8.7 (!ENP), U39.5 (1Y1)
-CNT2: U9.7 (!ENP), U9.10 (!ENT), U10.7 (!ENP), U11.7 (!ENP), U12.7 (!ENP), U39.6 (1Y2)
-CNT3: U13.7 (!ENP), U13.10 (!ENT), U14.7 (!ENP), U15.7 (!ENP), U16.7 (!ENP), U39.7 (1Y3)
-LDH: U30.14 (Y1), U37.13 (4B), U40.4 (2A), U40.12 (4A)
-LDH0: U32.12 (2Y0), U37.4 (2A)
-LDH0E: U3.9 (!LOAD), U4.9 (!LOAD), U37.6 (2Y)
-LDH1: U7.9 (!LOAD), U8.9 (!LOAD), U32.11 (2Y1)
-LDH2: U11.9 (!LOAD), U12.9 (!LOAD), U32.10 (2Y2)
-LDH3: U15.9 (!LOAD), U16.9 (!LOAD), U32.9 (2Y3)
-LDH4: U40.11 (4Y), U42.1 (!E)
-LDHG: U32.15 (!G2), U40.6 (2Y)
-LDL: U30.15 (Y0), U37.12 (4A), U40.1 (1A), U40.9 (3A)
-LDL0: U32.4 (1Y0), U37.1 (1A)
-LDL0E: U1.9 (!LOAD), U2.9 (!LOAD), U37.3 (1Y)
-LDL1: U5.9 (!LOAD), U6.9 (!LOAD), U32.5 (1Y1)
-LDL2: U9.9 (!LOAD), U10.9 (!LOAD), U32.6 (1Y2)
-LDL3: U13.9 (!LOAD), U14.9 (!LOAD), U32.7 (1Y3)
-LDL4: U40.8 (3Y), U41.1 (!E)
-LDLG: U32.1 (!G1), U40.3 (1Y)
-LDP: U37.11 (4Y), U38.4 (2A), U38.5 (2B)
-POE: U29.1 (!G1), U29.19 (!G2), U37.8 (3Y), U38.1 (1A), U38.2 (1B)
-POEH: U31.14 (Y1), U35.3 (2A), U37.10 (3B)
-POEL: U31.15 (Y0), U37.9 (3A)
-RES: J1.A11, U36.1 (!G1), U36.19 (!G2), U37.2 (1B), U37.5 (2B)
-SEL0: U17.1 (!G1), U17.19 (!G2), U18.1 (!G1), U18.19 (!G2), U33.15 (Y0)
-SEL1: U19.1 (!G1), U19.19 (!G2), U20.1 (!G1), U20.19 (!G2), U33.14 (Y1)
-SEL2: U21.1 (!G1), U21.19 (!G2), U22.1 (!G1), U22.19 (!G2), U33.13 (Y2)
-SEL3: U23.1 (!G1), U23.19 (!G2), U24.1 (!G1), U24.19 (!G2), U33.12 (Y3)
-SEL4: U33.11 (Y4), U40.10 (3B), U40.13 (4B), U43.1 (!G1), U43.19 (!G2), U44.1 (!G1), U44.19 (!G2)
A0: J1.C3, U25.18 (Y1)
A1: J1.C4, U25.16 (Y2)
A2: J1.C5, U25.14 (Y3)
A3: J1.C6, U25.12 (Y4)
A4: J1.C7, U25.9 (Y5)
A5: J1.C8, U25.7 (Y6)
A6: J1.C9, U25.5 (Y7)
A7: J1.C10, U25.3 (Y8)
A8: J1.C11, U26.18 (Y1)
A9: J1.C12, U26.16 (Y2)
A10: J1.C13, U26.14 (Y3)
A11: J1.C14, U26.12 (Y4)
A12: J1.C15, U26.9 (Y5)
A13: J1.C16, U26.7 (Y6)
A14: J1.C17, U26.5 (Y7)
A15: J1.C18, U26.3 (Y8)
CLK: J1.A24, U1.2 (CLK), U2.2 (CLK), U3.2 (CLK), U4.2 (CLK), U5.2 (CLK), U6.2 (CLK), U7.2 (CLK), U8.2 (CLK), U9.2 (CLK), U10.2 (CLK), U11.2 (CLK), U12.2 (CLK), U13.2 (CLK), U14.2 (CLK), U15.2 (CLK), U16.2 (CLK), U41.11 (CLK), U42.11 (CLK)
CNTN: U34.1 (1Y), U39.1 (!G1)
D0: J1.A3, U1.3 (A), U3.3 (A), U5.3 (A), U7.3 (A), U9.3 (A), U11.3 (A), U13.3 (A), U15.3 (A), U29.18 (Y1), U36.18 (Y1), U41.3 (D1), U42.3 (D1)
D1: J1.A4, U1.4 (B), U3.4 (B), U5.4 (B), U7.4 (B), U9.4 (B), U11.4 (B), U13.4 (B), U15.4 (B), U29.16 (Y2), U36.16 (Y2), U41.4 (D2), U42.4 (D2)
D2: J1.A5, U1.5 (C), U3.5 (C), U5.5 (C), U7.5 (C), U9.5 (C), U11.5 (C), U13.5 (C), U15.5 (C), U29.14 (Y3), U36.14 (Y3), U41.7 (D3), U42.7 (D3)
D3: J1.A6, U1.6 (D), U3.6 (D), U5.6 (D), U7.6 (D), U9.6 (D), U11.6 (D), U13.6 (D), U15.6 (D), U29.12 (Y4), U36.12 (Y4), U41.8 (D4), U42.8 (D4)
D4: J1.A7, U2.3 (A), U4.3 (A), U6.3 (A), U8.3 (A), U10.3 (A), U12.3 (A), U14.3 (A), U16.3 (A), U29.9 (Y5), U36.9 (Y5), U41.13 (D5), U42.13 (D5)
D5: J1.A8, U2.4 (B), U4.4 (B), U6.4 (B), U8.4 (B), U10.4 (B), U12.4 (B), U14.4 (B), U16.4 (B), U29.7 (Y6), U36.7 (Y6), U41.14 (D6), U42.14 (D6)
D6: J1.A9, U2.5 (C), U4.5 (C), U6.5 (C), U8.5 (C), U10.5 (C), U12.5 (C), U14.5 (C), U16.5 (C), U29.5 (Y7), U36.5 (Y7), U41.17 (D7), U42.17 (D7)
D7: J1.A10, U2.6 (D), U4.6 (D), U6.6 (D), U8.6 (D), U10.6 (D), U12.6 (D), U14.6 (D), U16.6 (D), U29.3 (Y8), U36.3 (Y8), U41.18 (D8), U42.18 (D8)
DLD0: J1.A16, U30.1 (A)
DLD1: J1.A17, U30.2 (B)
DLD2: J1.A18, U30.3 (C)
DLD3: J1.A19, U30.6 (G1)
DOE0: J1.A12, U31.1 (A)
DOE1: J1.A13, U31.2 (B)
DOE2: J1.A14, U31.3 (C)
DOE3: J1.A15, U31.6 (G1)
GND: CD1.2, CD2.2, CD3.2, CD4.2, CD5.2, CD6.2, CD7.2, CD8.2, CD9.2, CD10.2, CD11.2, CD12.2, CD13.2, CD14.2, CD15.2, CD16.2, CD17.2, CD18.2, CD19.2, CD20.2, CD21.2, CD22.2, CD23.2, CD24.2, CD25.2, CD26.2, CD27.2, CD28.2, CD29.2, CD30.2, CD31.2, CD32.2, CD33.2, CD34.2, CD35.2, CD36.2, CD37.2, CD38.2, CD39.2, CD40.2, CD41.2, CD42.2, CD43.2, CD44.2, J1.A31, J1.A32, J1.B3, J1.B5, J1.B7, J1.B9, J1.B11, J1.B13, J1.B15, J1.B17, J1.B19, J1.B21, J1.B23, J1.B25, J1.B31, J1.B32, J1.C31, J1.C32, LED3.1 (K), U1.8 (GND), U2.8 (GND), U3.8 (GND), U4.8 (GND), U5.8 (GND), U6.8 (GND), U7.8 (GND), U8.8 (GND), U9.8 (GND), U10.8 (GND), U11.8 (GND), U12.8 (GND), U13.8 (GND), U14.8 (GND), U15.8 (GND), U16.8 (GND), U17.10 (GND), U18.10 (GND), U19.10 (GND), U20.10 (GND), U21.10 (GND), U22.10 (GND), U23.10 (GND), U24.10 (GND), U25.1 (!G1), U25.10 (GND), U25.19 (!G2), U26.1 (!G1), U26.10 (GND), U26.19 (!G2), U27.8 (GND), U27.15 (!OE), U28.8 (GND), U28.15 (!OE), U29.10 (GND), U30.4 (!G2A), U30.5 (!G2B), U30.8 (GND), U31.4 (!G2A), U31.5 (!G2B), U31.8 (GND), U32.8 (GND), U33.4 (!G2A), U33.5 (!G2B), U33.8 (GND), U34.5 (2A), U34.6 (2B), U34.7 (GND), U34.8 (3A), U34.9 (3B), U34.11 (4A), U34.12 (4B), U35.5 (3A), U35.7 (GND), U35.9 (4A), U35.11 (5A), U35.13 (6A), U36.2 (A1), U36.4 (A2), U36.6 (A3), U36.8 (A4), U36.10 (GND), U36.11 (A5), U36.13 (A6), U36.15 (A7), U36.17 (A8), U37.7 (GND), U38.7 (GND), U38.9 (3A), U38.10 (3B), U38.12 (4A), U38.13 (4B), U39.8 (GND), U39.13 (B2), U39.14 (A2), U40.7 (GND), U41.10 (GND), U42.10 (GND), U43.10 (GND), U44.10 (GND)
LDK: LED5.1 (K), U38.6 (2Y)
LEDLD: LED5.2 (A), R5.2
LEDP: LED3.2 (A), RP1.2
LEDRD: LED4.2 (A), R4.2
PB0: U17.18 (Y1), U19.18 (Y1), U21.18 (Y1), U23.18 (Y1), U25.2 (A1), U27.2 (A1), U43.18 (Y1)
PB1: U17.16 (Y2), U19.16 (Y2), U21.16 (Y2), U23.16 (Y2), U25.4 (A2), U27.5 (A2), U43.16 (Y2)
PB2: U17.14 (Y3), U19.14 (Y3), U21.14 (Y3), U23.14 (Y3), U25.6 (A3), U27.11 (A3), U43.14 (Y3)
PB3: U17.12 (Y4), U19.12 (Y4), U21.12 (Y4), U23.12 (Y4), U25.8 (A4), U27.14 (A4), U43.12 (Y4)
PB4: U17.9 (Y5), U19.9 (Y5), U21.9 (Y5), U23.9 (Y5), U25.11 (A5), U28.2 (A1), U43.9 (Y5)
PB5: U17.7 (Y6), U19.7 (Y6), U21.7 (Y6), U23.7 (Y6), U25.13 (A6), U28.5 (A2), U43.7 (Y6)
PB6: U17.5 (Y7), U19.5 (Y7), U21.5 (Y7), U23.5 (Y7), U25.15 (A7), U28.11 (A3), U43.5 (Y7)
PB7: U17.3 (Y8), U19.3 (Y8), U21.3 (Y8), U23.3 (Y8), U25.17 (A8), U28.14 (A4), U43.3 (Y8)
PB8: U18.18 (Y1), U20.18 (Y1), U22.18 (Y1), U24.18 (Y1), U26.2 (A1), U27.3 (B1), U44.18 (Y1)
PB9: U18.16 (Y2), U20.16 (Y2), U22.16 (Y2), U24.16 (Y2), U26.4 (A2), U27.6 (B2), U44.16 (Y2)
PB10: U18.14 (Y3), U20.14 (Y3), U22.14 (Y3), U24.14 (Y3), U26.6 (A3), U27.10 (B3), U44.14 (Y3)
PB11: U18.12 (Y4), U20.12 (Y4), U22.12 (Y4), U24.12 (Y4), U26.8 (A4), U27.13 (B4), U44.12 (Y4)
PB12: U18.9 (Y5), U20.9 (Y5), U22.9 (Y5), U24.9 (Y5), U26.11 (A5), U28.3 (B1), U44.9 (Y5)
PB13: U18.7 (Y6), U20.7 (Y6), U22.7 (Y6), U24.7 (Y6), U26.13 (A6), U28.6 (B2), U44.7 (Y6)
PB14: U18.5 (Y7), U20.5 (Y7), U22.5 (Y7), U24.5 (Y7), U26.15 (A7), U28.10 (B3), U44.5 (Y7)
PB15: U18.3 (Y8), U20.3 (Y8), U22.3 (Y8), U24.3 (Y8), U26.17 (A8), U28.13 (B4), U44.3 (Y8)
PDEC: J1.A23, U34.3 (1B), U35.1 (1A)
PINC: J1.A22, U34.2 (1A)
POEHP: U27.1 (S), U28.1 (S), U35.4 (2Y)
PQ0_0: U1.14 (QA), U17.2 (A1)
PQ0_1: U1.13 (QB), U17.4 (A2)
PQ0_2: U1.12 (QC), U17.6 (A3)
PQ0_3: U1.11 (QD), U17.8 (A4)
PQ0_4: U2.14 (QA), U17.11 (A5)
PQ0_5: U2.13 (QB), U17.13 (A6)
PQ0_6: U2.12 (QC), U17.15 (A7)
PQ0_7: U2.11 (QD), U17.17 (A8)
PQ0_8: U3.14 (QA), U18.2 (A1)
PQ0_9: U3.13 (QB), U18.4 (A2)
PQ0_10: U3.12 (QC), U18.6 (A3)
PQ0_11: U3.11 (QD), U18.8 (A4)
PQ0_12: U4.14 (QA), U18.11 (A5)
PQ0_13: U4.13 (QB), U18.13 (A6)
PQ0_14: U4.12 (QC), U18.15 (A7)
PQ0_15: U4.11 (QD), U18.17 (A8)
PQ1_0: U5.14 (QA), U19.2 (A1)
PQ1_1: U5.13 (QB), U19.4 (A2)
PQ1_2: U5.12 (QC), U19.6 (A3)
PQ1_3: U5.11 (QD), U19.8 (A4)
PQ1_4: U6.14 (QA), U19.11 (A5)
PQ1_5: U6.13 (QB), U19.13 (A6)
PQ1_6: U6.12 (QC), U19.15 (A7)
PQ1_7: U6.11 (QD), U19.17 (A8)
PQ1_8: U7.14 (QA), U20.2 (A1)
PQ1_9: U7.13 (QB), U20.4 (A2)
PQ1_10: U7.12 (QC), U20.6 (A3)
PQ1_11: U7.11 (QD), U20.8 (A4)
PQ1_12: U8.14 (QA), U20.11 (A5)
PQ1_13: U8.13 (QB), U20.13 (A6)
PQ1_14: U8.12 (QC), U20.15 (A7)
PQ1_15: U8.11 (QD), U20.17 (A8)
PQ2_0: U9.14 (QA), U21.2 (A1)
PQ2_1: U9.13 (QB), U21.4 (A2)
PQ2_2: U9.12 (QC), U21.6 (A3)
PQ2_3: U9.11 (QD), U21.8 (A4)
PQ2_4: U10.14 (QA), U21.11 (A5)
PQ2_5: U10.13 (QB), U21.13 (A6)
PQ2_6: U10.12 (QC), U21.15 (A7)
PQ2_7: U10.11 (QD), U21.17 (A8)
PQ2_8: U11.14 (QA), U22.2 (A1)
PQ2_9: U11.13 (QB), U22.4 (A2)
PQ2_10: U11.12 (QC), U22.6 (A3)
PQ2_11: U11.11 (QD), U22.8 (A4)
PQ2_12: U12.14 (QA), U22.11 (A5)
PQ2_13: U12.13 (QB), U22.13 (A6)
PQ2_14: U12.12 (QC), U22.15 (A7)
PQ2_15: U12.11 (QD), U22.17 (A8)
PQ3_0: U13.14 (QA), U23.2 (A1)
PQ3_1: U13.13 (QB), U23.4 (A2)
PQ3_2: U13.12 (QC), U23.6 (A3)
PQ3_3: U13.11 (QD), U23.8 (A4)
PQ3_4: U14.14 (QA), U23.11 (A5)
PQ3_5: U14.13 (QB), U23.13 (A6)
PQ3_6: U14.12 (QC), U23.15 (A7)
PQ3_7: U14.11 (QD), U23.17 (A8)
PQ3_8: U15.14 (QA), U24.2 (A1)
PQ3_9: U15.13 (QB), U24.4 (A2)
PQ3_10: U15.12 (QC), U24.6 (A3)
PQ3_11: U15.11 (QD), U24.8 (A4)
PQ3_12: U16.14 (QA), U24.11 (A5)
PQ3_13: U16.13 (QB), U24.13 (A6)
PQ3_14: U16.12 (QC), U24.15 (A7)
PQ3_15: U16.11 (QD), U24.17 (A8)
PSEL0: J1.A20, U32.2 (A1), U32.14 (A2), U33.1 (A), U39.2 (A1)
PSEL1: J1.A21, U32.3 (B1), U32.13 (B2), U33.2 (B), U39.3 (B1)
PSEL2: J1.C27, U33.3 (C), U40.2 (1B), U40.5 (2B)
PTQ0_0: U41.2 (Q1), U43.2 (A1)
PTQ0_1: U41.5 (Q2), U43.4 (A2)
PTQ0_2: U41.6 (Q3), U43.6 (A3)
PTQ0_3: U41.9 (Q4), U43.8 (A4)
PTQ0_4: U41.12 (Q5), U43.11 (A5)
PTQ0_5: U41.15 (Q6), U43.13 (A6)
PTQ0_6: U41.16 (Q7), U43.15 (A7)
PTQ0_7: U41.19 (Q8), U43.17 (A8)
PTQ1_0: U42.2 (Q1), U44.2 (A1)
PTQ1_1: U42.5 (Q2), U44.4 (A2)
PTQ1_2: U42.6 (Q3), U44.6 (A3)
PTQ1_3: U42.9 (Q4), U44.8 (A4)
PTQ1_4: U42.12 (Q5), U44.11 (A5)
PTQ1_5: U42.15 (Q6), U44.13 (A6)
PTQ1_6: U42.16 (Q7), U44.15 (A7)
PTQ1_7: U42.19 (Q8), U44.17 (A8)
RB0: U27.4 (Y1), U29.2 (A1)
RB1: U27.7 (Y2), U29.4 (A2)
RB2: U27.9 (Y3), U29.6 (A3)
RB3: U27.12 (Y4), U29.8 (A4)
RB4: U28.4 (Y1), U29.11 (A5)
RB5: U28.7 (Y2), U29.13 (A6)
RB6: U28.9 (Y3), U29.15 (A7)
RB7: U28.12 (Y4), U29.17 (A8)
RC0_0: U1.15 (!RCO), U2.10 (!ENT)
RC0_1: U2.15 (!RCO), U3.10 (!ENT)
RC0_2: U3.15 (!RCO), U4.10 (!ENT)
RC1_0: U5.15 (!RCO), U6.10 (!ENT)
RC1_1: U6.15 (!RCO), U7.10 (!ENT)
RC1_2: U7.15 (!RCO), U8.10 (!ENT)
RC2_0: U9.15 (!RCO), U10.10 (!ENT)
RC2_1: U10.15 (!RCO), U11.10 (!ENT)
RC2_2: U11.15 (!RCO), U12.10 (!ENT)
RC3_0: U13.15 (!RCO), U14.10 (!ENT)
RC3_1: U14.15 (!RCO), U15.10 (!ENT)
RC3_2: U15.15 (!RCO), U16.10 (!ENT)
RDK: LED4.1 (K), U38.3 (1Y)
UDB: U1.1 (UD), U2.1 (UD), U3.1 (UD), U4.1 (UD), U5.1 (UD), U6.1 (UD), U7.1 (UD), U8.1 (UD), U9.1 (UD), U10.1 (UD), U11.1 (UD), U12.1 (UD), U13.1 (UD), U14.1 (UD), U15.1 (UD), U16.1 (UD), U35.2 (1Y)
VCC: CD1.1, CD2.1, CD3.1, CD4.1, CD5.1, CD6.1, CD7.1, CD8.1, CD9.1, CD10.1, CD11.1, CD12.1, CD13.1, CD14.1, CD15.1, CD16.1, CD17.1, CD18.1, CD19.1, CD20.1, CD21.1, CD22.1, CD23.1, CD24.1, CD25.1, CD26.1, CD27.1, CD28.1, CD29.1, CD30.1, CD31.1, CD32.1, CD33.1, CD34.1, CD35.1, CD36.1, CD37.1, CD38.1, CD39.1, CD40.1, CD41.1, CD42.1, CD43.1, CD44.1, J1.A1, J1.A2, J1.B1, J1.B2, J1.C1, J1.C2, R4.1, R5.1, RP1.1, U1.16 (VCC), U2.16 (VCC), U3.16 (VCC), U4.16 (VCC), U5.16 (VCC), U6.16 (VCC), U7.16 (VCC), U8.16 (VCC), U9.16 (VCC), U10.16 (VCC), U11.16 (VCC), U12.16 (VCC), U13.16 (VCC), U14.16 (VCC), U15.16 (VCC), U16.16 (VCC), U17.20 (VCC), U18.20 (VCC), U19.20 (VCC), U20.20 (VCC), U21.20 (VCC), U22.20 (VCC), U23.20 (VCC), U24.20 (VCC), U25.20 (VCC), U26.20 (VCC), U27.16 (VCC), U28.16 (VCC), U29.20 (VCC), U30.16 (VCC), U31.16 (VCC), U32.16 (VCC), U33.6 (G1), U33.16 (VCC), U34.14 (VCC), U35.14 (VCC), U36.20 (VCC), U37.14 (VCC), U38.14 (VCC), U39.15 (!G2), U39.16 (VCC), U40.14 (VCC), U41.20 (VCC), U42.20 (VCC), U43.20 (VCC), U44.20 (VCC)

Notes on the sheet:
P8X REGISTER BANK CARD REV B (P0=PC P3=SP, PT scratch)
P0 L0
74HCT169
P0 L1
P0 H0
P0 H1
P1 L0
P1 L1
P1 H0
P1 H1
P2 L0
P2 L1
P2 H0
P2 H1
P3 L0
P3 L1
P3 H0
P3 H1
PTR SEL 0
74HCT244
PTR SEL 1
PTR SEL 2
PTR SEL 3
PTR SEL 4
PTR SEL 5
PTR SEL 6
PTR SEL 7
ADDR LO
ADDR HI
RDBK LO
74HCT257
RDBK HI
RDBK OUT
DLD DEC
74HCT138
DOE DEC
LOAD DEC
74HCT139
SEL DEC
ZERO P0

Board: 4 copper layers, 95 parts (0 on the bottom side), 194 nets, no tracks yet.
